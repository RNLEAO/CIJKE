# Keil uVision project CIJIANKE_EM.uvproj, settings and files
target CIJIANKE_EM (MCS-251)
  device: AI32G12K128 Series AI
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: CIJIANKE_EM +hex
  asm include: ..\..\libraries\zf_common
  link misc: REMOVEUNUSED
  group startup
    ../../libraries/zf_common/: START251.A51 stc32gxx.h stc32g_isr.asm
  group doc
    ../../libraries/doc/: version.txt
  group zf_common
    ../../libraries/zf_common/: zf_common_headfile.h zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_typedef.c zf_common_typedef.h zf_common_interrupt.c zf_common_interrupt.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_eeprom.c zf_driver_eeprom.h zf_driver_exti.c zf_driver_exti.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h
  group zf_device
    ../../Libraries/zf_device/: zf_device_config.lib
    ../../libraries/zf_device/: zf_device_config.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_ips114.c zf_device_ips114.h zf_device_type.c zf_device_type.h zf_device_wireless_uart.c zf_device_wireless_uart.h
  group user_c
    ../user/: main.c isr.c
    ../code/: control_four.c menu_four.c Motor.c PID.c vofa.c element.c inductance4.c inductance4_menu.c out_control.c motion_runtime.c negative_pressure.c negative_pressure_menu.c
  group user_h
    ../code/: headfile.h common.h control.h menu.h Motor.h PID.h vofa.h element.h inductance4.h inductance4_menu.h out_control.h motion_runtime.h negative_pressure.h negative_pressure_menu.h
    ../user/: isr.h
  group compat
    ../code/: zf_adc.h legacy_compat.c legacy_compat.h legacy_lcd.c legacy_lcd.h legacy_font.c legacy_font.h SEEKFREE_FONT.h
